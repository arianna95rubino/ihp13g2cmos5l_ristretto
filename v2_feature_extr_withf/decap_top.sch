v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
N 110 -230 110 -200 {lab=top}
N 110 -80 110 -40 {lab=vss}
C {decap_unit.sym} 110 -140 0 0 {name=x1}
C {iopin.sym} 110 -230 2 0 {name=pin_top lab=top}
C {iopin.sym} 110 -40 2 0 {name=pin_bot lab=bot}
