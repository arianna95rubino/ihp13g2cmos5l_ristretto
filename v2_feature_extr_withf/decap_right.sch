v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
N 130 -320 130 -270 {lab=top}
N 130 -150 130 -100 {lab=vss}
C {iopin.sym} 130 -320 3 0 {name=pin_top lab=top}
C {iopin.sym} 130 -100 1 0 {name=pin_bot lab=bot}
C {decap_unit.sym} 130 -210 0 0 {name=x1}
