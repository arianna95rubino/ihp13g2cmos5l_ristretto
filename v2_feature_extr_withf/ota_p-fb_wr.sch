v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
N 570 -780 570 -730 {
lab=vdd}
N 210 -680 480 -680 {
lab=vp}
N 550 -570 550 -530 {lab=vss}
N 590 -570 590 -530 {lab=vbias}
N 590 -530 620 -530 {lab=vbias}
N 500 -530 550 -530 {lab=vss}
N 510 -780 570 -780 {lab=vdd}
N 720 -650 800 -650 {
lab=vout}
N 400 -620 480 -620 {lab=vin_f}
N 650 -650 720 -650 {
lab=vout}
N 617.5 -290 720 -290 {lab=vout}
N 400 -290 495 -290 {lab=#net1}
N 400 -340 400 -290 {lab=#net1}
N 720 -650 720 -290 {lab=vout}
N 400 -620 400 -400 {lab=vin_f}
N 210 -620 300 -620 {lab=vn}
N 360 -620 400 -620 {lab=vin_f}
N 80 -410 120 -410 {lab=vss}
N 80 -410 80 -340 {lab=vss}
N 80 -340 220 -340 {lab=vss}
N 220 -410 220 -340 {lab=vss}
N 180 -410 220 -410 {lab=vss}
N 80 -500 120 -500 {lab=vss}
N 80 -500 80 -410 {lab=vss}
N 180 -500 220 -500 {lab=vss}
N 220 -500 220 -410 {lab=vss}
N 330 -1240 330 -1140 {lab=vss}
N 310 -970 310 -910 {lab=vss}
N 330 -950 330 -870 {lab=vss}
N 430 -970 430 -910 {lab=vss}
N 450 -950 450 -870 {lab=vss}
N 450 -1240 450 -1140 {lab=vss}
N 540 -970 540 -910 {lab=vss}
N 560 -950 560 -870 {lab=vss}
N 450 -1240 560 -1240 {lab=vss}
N 560 -1240 560 -1140 {lab=vss}
N 450 -870 560 -870 {lab=vss}
N 330 -870 450 -870 {lab=vss}
N 330 -1240 450 -1240 {lab=vss}
N 660 -970 660 -910 {lab=vss}
N 680 -950 680 -870 {lab=vss}
N 680 -1240 680 -1140 {lab=vss}
N 560 -870 680 -870 {lab=vss}
N 560 -1240 680 -1240 {lab=vss}
N 430 -1480 480 -1480 {lab=vdd}
N 430 -1480 430 -1380 {lab=vdd}
N 510 -1440 510 -1360 {lab=vin_f}
N 510 -1620 510 -1520 {lab=vout}
N 840 -1140 840 -1080 {lab=vss}
N 840 -1020 840 -950 {lab=vss}
N 950 -1050 1000 -1050 {lab=vdd}
N 950 -1050 950 -950 {lab=vdd}
N 1030 -1010 1030 -930 {lab=vn}
N 1030 -1190 1030 -1090 {lab=vin_f}
N 780 -1140 840 -1140 {lab=vss}
N 780 -1140 780 -950 {lab=vss}
N 780 -950 840 -950 {lab=vss}
N 510 -1520 580 -1520 {lab=vout}
N 510 -1440 580 -1440 {lab=vin_f}
N 610 -1480 660 -1480 {lab=vdd}
N 660 -1480 660 -1380 {lab=vdd}
N 1140 -1050 1190 -1050 {lab=vdd}
N 1190 -1050 1190 -950 {lab=vdd}
N 1030 -1090 1110 -1090 {lab=vin_f}
N 1030 -1010 1110 -1010 {lab=vn}
N 1290 -1050 1340 -1050 {lab=vdd}
N 1290 -1050 1290 -950 {lab=vdd}
N 1370 -1010 1370 -930 {lab=vn}
N 1370 -1190 1370 -1090 {lab=vin_f}
N 1480 -1050 1530 -1050 {lab=vdd}
N 1530 -1050 1530 -950 {lab=vdd}
N 1370 -1090 1450 -1090 {lab=vin_f}
N 1370 -1010 1450 -1010 {lab=vn}
N 1030 -1190 1370 -1190 {lab=vin_f}
N 1030 -930 1370 -930 {lab=vn}
N 1620 -1050 1670 -1050 {lab=vss}
N 1620 -1050 1620 -950 {lab=vss}
N 1700 -1010 1700 -930 {lab=vn}
N 1700 -1190 1700 -1090 {lab=vin_f}
N 1810 -1050 1860 -1050 {lab=vdd}
N 1860 -1050 1860 -950 {lab=vdd}
N 1700 -1090 1780 -1090 {lab=vin_f}
N 1700 -1010 1780 -1010 {lab=vn}
N 1960 -1050 2010 -1050 {lab=vdd}
N 1960 -1050 1960 -950 {lab=vdd}
N 2040 -1010 2040 -930 {lab=vn}
N 2040 -1190 2040 -1090 {lab=vin_f}
N 2150 -1050 2200 -1050 {lab=vdd}
N 2200 -1050 2200 -950 {lab=vdd}
N 2040 -1090 2120 -1090 {lab=vin_f}
N 2040 -1010 2120 -1010 {lab=vn}
N 1700 -1190 2040 -1190 {lab=vin_f}
N 1370 -1190 1700 -1190 {lab=vin_f}
N 1700 -930 2040 -930 {lab=vn}
N 1370 -930 1700 -930 {lab=vn}
C {ota_p-wr.sym} 550 -650 0 0 {name=xota}
C {ipin.sym} 210 -680 0 0 {name=pin_vp lab=vp}
C {ipin.sym} 210 -620 0 0 {name=pin_vn lab=vn}
C {ipin.sym} 620 -530 2 0 {name=pin_vbias lab=vbias}
C {iopin.sym} 510 -780 2 0 {name=pin_vdd lab=vdd}
C {iopin.sym} 500 -530 2 0 {name=pin_vss lab=vss}
C {opin.sym} 800 -650 0 0 {name=pin_vout lab=vout}
C {capa.sym} 150 -500 1 0 {name=C2
m=1
value=0.5p
footprint=1206
device="ceramic capacitor"}
C {pseudo_res.sym} 550 -292.5 0 0 {name=x1}
C {ammeter.sym} 400 -370 0 0 {name=Vmeas savecurrent=true spice_ignore=0}
C {capa.sym} 150 -410 1 0 {name=C5
m=1
value=50p
footprint=1206
device="ceramic capacitor"}
C {lab_wire.sym} 80 -340 0 0 {name=p2 sig_type=std_logic lab=vss}
C {lab_wire.sym} 300 -620 0 0 {name=p3 sig_type=std_logic lab=vn}
C {lab_wire.sym} 360 -620 2 0 {name=p4 sig_type=std_logic lab=vin_f}
C {devices/lab_pin.sym} 330 -880 0 0 {name=p8 sig_type=std_logic lab=vss}
C {devices/lab_pin.sym} 310 -910 0 0 {name=p10 sig_type=std_logic lab=vss}
C {cap_mos.sym} 450 -1050 0 0 {name=x2}
C {devices/lab_pin.sym} 430 -910 0 0 {name=p11 sig_type=std_logic lab=vss}
C {cap_mos.sym} 330 -1050 0 0 {name=x6}
C {cap_mos.sym} 560 -1050 0 0 {name=x3}
C {devices/lab_pin.sym} 540 -910 0 0 {name=p1 sig_type=std_logic lab=vss}
C {cap_mos.sym} 680 -1050 0 0 {name=x4}
C {devices/lab_pin.sym} 660 -910 0 0 {name=p5 sig_type=std_logic lab=vss}
C {sg13cmos5l_pr/sg13_svaricap.sym} 510 -1480 3 1 {name=C1 
model=sg13_hv_svaricap 
w=3.74u 
l=0.3u 
Nx=1
spiceprefix=X
}
C {devices/lab_pin.sym} 430 -1390 0 0 {name=p38 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} 330 -1240 0 0 {name=p7 sig_type=std_logic lab=vss}
C {devices/lab_pin.sym} 780 -650 0 0 {name=p40 sig_type=std_logic lab=vout}
C {devices/lab_pin.sym} 510 -1370 0 0 {name=p41 sig_type=std_logic lab=vin_f}
C {devices/lab_pin.sym} 510 -1550 0 0 {name=p42 sig_type=std_logic lab=vout}
C {capa.sym} 840 -1050 0 0 {name=C3
m=1
value=50p
footprint=1206
device="ceramic capacitor"}
C {sg13cmos5l_pr/sg13_svaricap.sym} 1030 -1050 3 1 {name=C4 
model=sg13_hv_svaricap 
w=3.74u 
l=0.3u 
Nx=1
spiceprefix=X
}
C {devices/lab_pin.sym} 950 -960 0 0 {name=p6 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} 1030 -1170 0 0 {name=p13 sig_type=std_logic lab=vin_f}
C {devices/lab_pin.sym} 1030 -960 0 0 {name=p14 sig_type=std_logic lab=vn}
C {devices/lab_pin.sym} 820 -950 0 0 {name=p9 sig_type=std_logic lab=vss}
C {devices/lab_pin.sym} 810 -1140 0 0 {name=p15 sig_type=std_logic lab=vss}
C {sg13cmos5l_pr/sg13_svaricap.sym} 580 -1480 1 0 {name=C21 
model=sg13_hv_svaricap 
w=3.74u 
l=0.3u 
Nx=1
spiceprefix=X
}
C {devices/lab_pin.sym} 660 -1390 0 1 {name=p12 sig_type=std_logic lab=vdd}
C {sg13cmos5l_pr/sg13_svaricap.sym} 1110 -1050 1 0 {name=C6 
model=sg13_hv_svaricap 
w=3.74u 
l=0.3u 
Nx=1
spiceprefix=X
}
C {devices/lab_pin.sym} 1190 -960 0 1 {name=p16 sig_type=std_logic lab=vdd}
C {sg13cmos5l_pr/sg13_svaricap.sym} 1370 -1050 3 1 {name=C7 
model=sg13_hv_svaricap 
w=3.74u 
l=0.3u 
Nx=1
spiceprefix=X
}
C {devices/lab_pin.sym} 1290 -960 0 0 {name=p17 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} 1370 -960 0 0 {name=p18 sig_type=std_logic lab=vn}
C {sg13cmos5l_pr/sg13_svaricap.sym} 1450 -1050 1 0 {name=C8 
model=sg13_hv_svaricap 
w=3.74u 
l=0.3u 
Nx=1
spiceprefix=X
}
C {devices/lab_pin.sym} 1530 -960 0 1 {name=p19 sig_type=std_logic lab=vdd}
C {sg13cmos5l_pr/sg13_svaricap.sym} 1700 -1050 3 1 {name=C9 
model=sg13_hv_svaricap 
w=3.74u 
l=0.3u 
Nx=1
spiceprefix=X
}
C {devices/lab_pin.sym} 1620 -960 0 0 {name=p20 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} 1700 -1170 0 0 {name=p21 sig_type=std_logic lab=vin_f}
C {devices/lab_pin.sym} 1700 -960 0 0 {name=p22 sig_type=std_logic lab=vn}
C {sg13cmos5l_pr/sg13_svaricap.sym} 1780 -1050 1 0 {name=C10 
model=sg13_hv_svaricap 
w=3.74u 
l=0.3u 
Nx=1
spiceprefix=X
}
C {devices/lab_pin.sym} 1860 -960 0 1 {name=p23 sig_type=std_logic lab=vdd}
C {sg13cmos5l_pr/sg13_svaricap.sym} 2040 -1050 3 1 {name=C11 
model=sg13_hv_svaricap 
w=3.74u 
l=0.3u 
Nx=1
spiceprefix=X
}
C {devices/lab_pin.sym} 1960 -960 0 0 {name=p24 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} 2040 -960 0 0 {name=p25 sig_type=std_logic lab=vn}
C {sg13cmos5l_pr/sg13_svaricap.sym} 2120 -1050 1 0 {name=C12 
model=sg13_hv_svaricap 
w=3.74u 
l=0.3u 
Nx=1
spiceprefix=X
}
C {devices/lab_pin.sym} 2200 -960 0 1 {name=p26 sig_type=std_logic lab=vdd}
