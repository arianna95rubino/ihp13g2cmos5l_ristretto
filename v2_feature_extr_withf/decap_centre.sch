v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
N 110 -280 110 -230 {lab=top}
N 110 -110 110 -60 {lab=vss}
C {iopin.sym} 110 -280 3 0 {name=pin_top lab=top}
C {iopin.sym} 110 -60 1 0 {name=pin_bot lab=bot}
C {decap_unit.sym} 110 -170 0 0 {name=x1}
