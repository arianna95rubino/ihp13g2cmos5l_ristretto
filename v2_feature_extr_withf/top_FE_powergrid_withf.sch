v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
N 90 -710 90 -660 {lab=vdd}
N 250 -710 330 -710 {lab=vdd}
N 330 -710 330 -660 {lab=vdd}
N 250 -710 250 -660 {lab=vdd}
N 170 -710 250 -710 {lab=vdd}
N 170 -710 170 -660 {lab=vdd}
N 90 -710 170 -710 {lab=vdd}
N 90 -540 90 -500 {lab=vss}
N 330 -540 330 -500 {lab=vss}
N 250 -500 330 -500 {lab=vss}
N 170 -540 170 -500 {lab=vss}
N 90 -500 170 -500 {lab=vss}
N 250 -540 250 -500 {lab=vss}
N 170 -500 250 -500 {lab=vss}
N 470 -710 470 -660 {lab=vdd}
N 890 -710 960 -710 {lab=vdd}
N 960 -710 960 -660 {lab=vdd}
N 890 -710 890 -660 {lab=vdd}
N 820 -710 890 -710 {lab=vdd}
N 820 -710 820 -660 {lab=vdd}
N 750 -710 820 -710 {lab=vdd}
N 750 -710 750 -660 {lab=vdd}
N 680 -710 750 -710 {lab=vdd}
N 680 -710 680 -660 {lab=vdd}
N 610 -710 680 -710 {lab=vdd}
N 610 -710 610 -660 {lab=vdd}
N 540 -710 610 -710 {lab=vdd}
N 540 -710 540 -660 {lab=vdd}
N 470 -710 540 -710 {lab=vdd}
N 470 -540 470 -490 {lab=vss}
N 890 -490 960 -490 {lab=vss}
N 960 -540 960 -490 {lab=vss}
N 890 -540 890 -490 {lab=vss}
N 820 -490 890 -490 {lab=vss}
N 820 -540 820 -490 {lab=vss}
N 750 -490 820 -490 {lab=vss}
N 750 -540 750 -490 {lab=vss}
N 680 -490 750 -490 {lab=vss}
N 680 -540 680 -490 {lab=vss}
N 610 -490 680 -490 {lab=vss}
N 610 -540 610 -490 {lab=vss}
N 540 -490 610 -490 {lab=vss}
N 540 -540 540 -490 {lab=vss}
N 470 -490 540 -490 {lab=vss}
N 470 -460 470 -410 {lab=vdd}
N 890 -460 960 -460 {lab=vdd}
N 960 -460 960 -410 {lab=vdd}
N 890 -460 890 -410 {lab=vdd}
N 820 -460 890 -460 {lab=vdd}
N 820 -460 820 -410 {lab=vdd}
N 750 -460 820 -460 {lab=vdd}
N 750 -460 750 -410 {lab=vdd}
N 680 -460 750 -460 {lab=vdd}
N 680 -460 680 -410 {lab=vdd}
N 610 -460 680 -460 {lab=vdd}
N 610 -460 610 -410 {lab=vdd}
N 540 -460 610 -460 {lab=vdd}
N 540 -460 540 -410 {lab=vdd}
N 470 -460 540 -460 {lab=vdd}
N 470 -290 470 -240 {lab=vss}
N 890 -240 960 -240 {lab=vss}
N 960 -290 960 -240 {lab=vss}
N 890 -290 890 -240 {lab=vss}
N 820 -240 890 -240 {lab=vss}
N 820 -290 820 -240 {lab=vss}
N 750 -240 820 -240 {lab=vss}
N 750 -290 750 -240 {lab=vss}
N 680 -240 750 -240 {lab=vss}
N 680 -290 680 -240 {lab=vss}
N 610 -240 680 -240 {lab=vss}
N 610 -290 610 -240 {lab=vss}
N 540 -240 610 -240 {lab=vss}
N 540 -290 540 -240 {lab=vss}
N 470 -240 540 -240 {lab=vss}
N 1170 -540 1170 -490 {lab=vss}
N 1170 -710 1170 -660 {lab=vdd}
N 600 -990 600 -940 {lab=vdd}
N 740 -990 820 -990 {lab=vdd}
N 820 -990 820 -940 {lab=vdd}
N 740 -990 740 -940 {lab=vdd}
N 670 -990 740 -990 {lab=vdd}
N 670 -990 670 -940 {lab=vdd}
N 600 -990 670 -990 {lab=vdd}
N 600 -820 600 -770 {lab=vss}
N 740 -770 820 -770 {lab=vss}
N 820 -820 820 -770 {lab=vss}
N 740 -820 740 -770 {lab=vss}
N 670 -770 740 -770 {lab=vss}
N 670 -820 670 -770 {lab=vss}
N 600 -770 670 -770 {lab=vss}
N 690 -200 770 -200 {lab=vdd}
N 610 -200 610 -160 {lab=vdd}
N 690 -200 690 -160 {lab=vdd}
N 610 -200 690 -200 {lab=vdd}
N 770 -200 770 -160 {lab=vdd}
N 610 -40 610 0 {lab=vss}
N 690 0 770 0 {lab=vss}
N 770 -40 770 0 {lab=vss}
N 690 -40 690 0 {lab=vss}
N 610 0 690 0 {lab=vss}
C {decap_bottom.sym} 610 -100 0 0 {name=x1}
C {decap_right.sym} 1170 -600 0 0 {name=x2}
C {decap_left.sym} 90 -600 0 0 {name=x3}
C {decap_centre.sym} 470 -600 0 0 {name=x4}
C {decap_top.sym} 600 -880 0 0 {name=x5}
C {decap_left.sym} 170 -600 0 0 {name=x6}
C {decap_left.sym} 250 -600 0 0 {name=x7}
C {decap_left.sym} 330 -600 0 0 {name=x8}
C {decap_bottom.sym} 690 -100 0 0 {name=x9}
C {decap_bottom.sym} 770 -100 0 0 {name=x10}
C {decap_top.sym} 670 -880 0 0 {name=x11}
C {decap_top.sym} 740 -880 0 0 {name=x12}
C {decap_top.sym} 820 -880 0 0 {name=x13}
C {decap_centre.sym} 540 -600 0 0 {name=x14}
C {decap_centre.sym} 610 -600 0 0 {name=x15}
C {decap_centre.sym} 680 -600 0 0 {name=x16}
C {decap_centre.sym} 750 -600 0 0 {name=x17}
C {decap_centre.sym} 820 -600 0 0 {name=x18}
C {decap_centre.sym} 890 -600 0 0 {name=x19}
C {decap_centre.sym} 960 -600 0 0 {name=x20}
C {lab_wire.sym} 210 -710 0 0 {name=p1 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 210 -500 0 0 {name=p2 sig_type=std_logic lab=vss}
C {lab_wire.sym} 700 -710 0 0 {name=p3 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 720 -490 0 0 {name=p4 sig_type=std_logic lab=vss}
C {decap_centre.sym} 470 -350 0 0 {name=x21}
C {decap_centre.sym} 540 -350 0 0 {name=x22}
C {decap_centre.sym} 610 -350 0 0 {name=x23}
C {decap_centre.sym} 680 -350 0 0 {name=x24}
C {decap_centre.sym} 750 -350 0 0 {name=x25}
C {decap_centre.sym} 820 -350 0 0 {name=x26}
C {decap_centre.sym} 890 -350 0 0 {name=x27}
C {decap_centre.sym} 960 -350 0 0 {name=x28}
C {lab_wire.sym} 700 -460 0 0 {name=p5 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 720 -240 0 0 {name=p6 sig_type=std_logic lab=vss}
C {lab_wire.sym} 1170 -680 0 0 {name=p7 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 1170 -510 0 0 {name=p8 sig_type=std_logic lab=vss}
C {lab_wire.sym} 720 -990 0 0 {name=p9 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 710 -770 0 0 {name=p10 sig_type=std_logic lab=vss}
C {lab_wire.sym} 720 0 0 0 {name=p11 sig_type=std_logic lab=vss}
C {lab_wire.sym} 720 -200 0 0 {name=p12 sig_type=std_logic lab=vdd}
C {iopin.sym} 150 -860 0 0 {name=pin_vdd lab=vdd}
C {iopin.sym} 150 -830 0 0 {name=pin_vss lab=vss}
