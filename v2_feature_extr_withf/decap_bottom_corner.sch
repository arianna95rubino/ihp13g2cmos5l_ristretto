v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
N 100 -220 100 -180 {lab=top}
N 100 -60 100 -20 {lab=vss}
C {decap_unit_bottom.sym} 100 -120 0 0 {name=x1}
C {iopin.sym} 100 -220 2 0 {name=pin_top lab=top}
C {iopin.sym} 100 -20 2 0 {name=pin_bot lab=bot}
