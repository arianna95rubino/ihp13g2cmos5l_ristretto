v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
N -1180 540 -1120 540 {lab=vin_p_ch1_out}
N -1180 660 -1120 660 {lab=vin_n_ch1_out}
N -1180 780 -1120 780 {lab=vin_p_ch2_out}
N -1180 900 -1120 900 {lab=vin_n_ch2_out}
N -1180 1020 -1120 1020 {lab=vthr_h_out}
N -1180 1140 -1120 1140 {lab=vthr_l_out}
N -1430 580 -1370 580 {lab=vin_p_ch1_in}
N -1430 700 -1370 700 {lab=vin_n_ch1_in}
N -1430 820 -1370 820 {lab=vin_p_ch2_in}
N -1430 940 -1370 940 {lab=vin_n_ch2_in}
N -1430 1060 -1370 1060 {lab=vthr_h_in}
N -1430 1180 -1370 1180 {lab=vthr_l_in}
N -1420 -490 -1330 -490 {lab=iovss}
N -1420 -450 -1290 -450 {lab=iovdd}
N -1420 -410 -1250 -410 {lab=vdd}
N -1420 -370 -1210 -370 {lab=vss}
N -2950 330 -2420 330 {lab=vss}
N -1180 180 -1130 180 {lab=vout_amp_in}
N -1180 60 -1130 60 {lab=vout_up_in}
N -1180 -60 -1130 -60 {lab=vout_dn_in}
N -1180 420 -1130 420 {lab=vbias_out}
N -20 -340 -20 -290 {lab=vbias_bufN_out}
N -1180 300 -1130 300 {lab=vbias_bufP_out}
N -1180 -140 -1130 -140 {lab=ch_sel_out}
N -1420 340 -1370 340 {lab=vbias_bufP_in}
N -60 -580 -60 -530 {lab=vbias_bufN_in}
N -1420 460 -1370 460 {lab=vbias_in}
N -1420 -160 -1370 -160 {lab=ch_sel_in}
N -1420 -20 -1370 -20 {lab=vout_dn_out}
N -1420 100 -1370 100 {lab=vout_up_out}
N -1420 220 -1370 220 {lab=vout_amp_out}
N -780 -580 -780 -530 {lab=vgain_in}
N -660 -580 -660 -530 {lab=vleak_in}
N -540 -580 -540 -530 {lab=vspkthr_in}
N -420 -580 -420 -530 {lab=vref_in}
N -300 -580 -300 -530 {lab=vmem_up_out}
N -180 -580 -180 -530 {lab=vmem_dn_out}
N 80 -580 80 -530 {lab=req_up_out}
N 200 -580 200 -530 {lab=req_dn_out}
N -740 -340 -740 -290 {lab=vgain_out}
N -620 -340 -620 -290 {lab=vleak_out}
N -500 -340 -500 -290 {lab=vspkthr_out}
N -380 -340 -380 -290 {lab=vref_out}
N -260 -340 -260 -290 {lab=vmem_up_in}
N -140 -340 -140 -290 {lab=vmem_dn_in}
N 120 -340 120 -290 {lab=req_up_in}
N 240 -340 240 -290 {lab=req_dn_in}
N 440 -570 440 -530 {lab=ack_up_in}
N 420 -340 420 -290 {lab=ack_up_out}
N 320 -570 320 -530 {lab=ack_dn_in}
N 300 -340 300 -290 {lab=ack_dn_out}
N -2950 580 -2420 580 {lab=vss}
N -2950 620 -2420 620 {lab=vdd}
N -2950 660 -2420 660 {lab=iovdd}
N -2950 700 -2420 700 {lab=iovss}
N -840 1870 -130 1870 {lab=vss}
N -840 1910 -130 1910 {lab=vdd}
N -840 1950 -130 1950 {lab=iovdd}
N -840 1990 -130 1990 {lab=iovss}
N -840 2110 -130 2110 {lab=vss}
N -840 2150 -130 2150 {lab=vdd}
N -840 2190 -130 2190 {lab=iovdd}
N -840 2230 -130 2230 {lab=iovss}
N -840 2350 -130 2350 {lab=vss}
N -840 2390 -130 2390 {lab=vdd}
N -840 2430 -130 2430 {lab=iovdd}
N -840 2470 -130 2470 {lab=iovss}
N -850 2580 -140 2580 {lab=vss}
N -850 2620 -140 2620 {lab=vdd}
N -850 2660 -140 2660 {lab=iovdd}
N -850 2700 -140 2700 {lab=iovss}
N 1870 500 2400 500 {lab=vss}
N 1870 540 2400 540 {lab=vdd}
N 1870 580 2400 580 {lab=iovdd}
N 1870 620 2400 620 {lab=iovss}
N -190 -1750 520 -1750 {lab=vss}
N -190 -1710 520 -1710 {lab=vdd}
N -190 -1670 520 -1670 {lab=iovdd}
N -190 -1630 520 -1630 {lab=iovss}
N -190 -1510 520 -1510 {lab=vss}
N -190 -1470 520 -1470 {lab=vdd}
N -190 -1430 520 -1430 {lab=iovdd}
N -190 -1390 520 -1390 {lab=iovss}
N -190 -1270 520 -1270 {lab=vss}
N -190 -1230 520 -1230 {lab=vdd}
N -190 -1190 520 -1190 {lab=iovdd}
N -190 -1150 520 -1150 {lab=iovss}
N -200 -1040 510 -1040 {lab=vss}
N -200 -1000 510 -1000 {lab=vdd}
N -200 -960 510 -960 {lab=iovdd}
N -200 -920 510 -920 {lab=iovss}
N -2730 840 -2650 840 {lab=vss}
N -2730 880 -2650 880 {lab=vdd}
N -2730 920 -2650 920 {lab=iovdd}
N -2730 960 -2650 960 {lab=iovss}
N 2090 760 2170 760 {lab=vss}
N 2090 800 2170 800 {lab=vdd}
N 2090 840 2170 840 {lab=iovdd}
N 2090 880 2170 880 {lab=iovss}
N -2950 370 -2420 370 {lab=vdd}
N -2950 410 -2420 410 {lab=iovdd}
N -2950 450 -2420 450 {lab=iovss}
N -1210 1370 1010 1370 {lab=vss}
N -1210 -370 -1210 1370 {lab=vss}
N -1250 1410 1050 1410 {lab=vdd}
N -1290 1450 1090 1450 {lab=iovdd}
N -1290 -450 -1290 1450 {lab=iovdd}
N -1330 1490 1130 1490 {lab=iovss}
N -1330 -490 -1330 1490 {lab=iovss}
N 1010 -370 1010 1370 {lab=vss}
N 1050 -410 1050 1410 {lab=vdd}
N 1090 -450 1090 1450 {lab=iovdd}
N 1130 -490 1130 1490 {lab=iovss}
N -1210 -370 1010 -370 {lab=vss}
N -1290 -450 1090 -450 {lab=iovdd}
N -1250 -410 1050 -410 {lab=vdd}
N 1860 240 2390 240 {lab=vss}
N 1860 280 2390 280 {lab=vdd}
N 1860 320 2390 320 {lab=iovdd}
N 1860 360 2390 360 {lab=iovss}
N 170 1860 880 1860 {lab=vss}
N 170 1900 880 1900 {lab=vdd}
N 170 1940 880 1940 {lab=iovdd}
N 170 1980 880 1980 {lab=iovss}
N -1090 -1230 -380 -1230 {lab=vdd}
N -1090 -1190 -380 -1190 {lab=iovdd}
N -1090 -1150 -380 -1150 {lab=iovss}
N -1090 -1270 -380 -1270 {lab=vss}
N -1330 -490 1130 -490 {lab=iovss}
N -1250 -410 -1250 1410 {lab=vdd}
N -620 1530 -620 1580 {lab=vgain_in}
N -660 1290 -660 1340 {lab=vgain_in}
N -500 1530 -500 1580 {lab=vgain_in}
N -540 1290 -540 1340 {lab=vgain_in}
N -420 1290 -420 1340 {lab=vgain_in}
N -380 1530 -380 1580 {lab=vgain_in}
N -300 1290 -300 1340 {lab=vgain_in}
N -260 1530 -260 1580 {lab=vgain_in}
N -140 1530 -140 1580 {lab=vgain_in}
N -180 1290 -180 1340 {lab=vgain_in}
N -60 1290 -60 1340 {lab=vgain_in}
N -20 1530 -20 1580 {lab=vgain_in}
N 60 1290 60 1340 {lab=vgain_in}
N 100 1530 100 1580 {lab=vgain_in}
N 180 1290 180 1340 {lab=vgain_in}
N 220 1530 220 1580 {lab=vgain_in}
N 300 1290 300 1340 {lab=vgain_in}
N 340 1530 340 1580 {lab=vgain_in}
N 460 1290 460 1340 {lab=vgain_in}
N 440 1530 440 1580 {lab=vgain_in}
N 520 1290 520 1340 {lab=vgain_in}
N 560 1530 560 1580 {lab=vgain_in}
N 1170 1160 1230 1160 {lab=vthr_l_out}
N 920 1140 980 1140 {lab=vthr_l_out}
N 1170 1040 1230 1040 {lab=vthr_l_out}
N 1170 920 1230 920 {lab=vthr_l_out}
N 1170 800 1230 800 {lab=vthr_l_out}
N 1170 680 1230 680 {lab=vthr_l_out}
N 1170 560 1230 560 {lab=vthr_l_out}
N 1170 440 1230 440 {lab=vthr_l_out}
N 1170 320 1230 320 {lab=vthr_l_out}
N 1170 200 1230 200 {lab=vthr_l_out}
N 1170 80 1230 80 {lab=vthr_l_out}
N 1170 -40 1230 -40 {lab=vthr_l_out}
N 1170 -160 1230 -160 {lab=vthr_l_out}
N 920 -180 980 -180 {lab=vthr_l_out}
N 920 0 980 0 {lab=vthr_l_out}
N 920 60 980 60 {lab=vthr_l_out}
N 920 180 980 180 {lab=vthr_l_out}
N 920 300 980 300 {lab=vthr_l_out}
N 920 480 980 480 {lab=vthr_l_out}
N 920 720 980 720 {lab=vthr_l_out}
N 920 900 980 900 {lab=vthr_l_out}
N 920 540 980 540 {lab=vthr_l_out}
N 920 1080 980 1080 {lab=vthr_l_out}
N 920 840 980 840 {lab=vthr_l_out}
N 560 -570 560 -530 {lab=ack_up_in}
N 540 -340 540 -290 {lab=ack_up_out}
C {sg13cmos5l_IOPadAnalog.sym} -1280 560 1 0 {name=x1}
C {sg13cmos5l_IOPadAnalog.sym} -1280 680 1 0 {name=x6}
C {sg13cmos5l_IOPadAnalog.sym} -1280 800 1 0 {name=x7}
C {sg13cmos5l_IOPadAnalog.sym} -1280 920 1 0 {name=x8}
C {sg13cmos5l_IOPadAnalog.sym} -1280 1040 1 0 {name=x9}
C {sg13cmos5l_IOPadAnalog.sym} -1280 1160 1 0 {name=x10}
C {sg13cmos5l_IOPadVdd.sym} 1070 -280 3 0 {name=x16}
C {sg13cmos5l_IOPadIn.sym} 1080 -160 3 0 {name=x17}
C {sg13cmos5l_IOPadIn.sym} 1080 200 3 0 {name=x18}
C {sg13cmos5l_IOPadIn.sym} 1080 80 3 0 {name=x19}
C {sg13cmos5l_IOPadOut16mA.sym} 1080 1040 3 0 {name=x25}
C {sg13cmos5l_IOPadIn.sym} 1080 1160 3 0 {name=x26}
C {sg13cmos5l_IOPadIOVdd.sym} 1080 1280 3 0 {name=x27}
C {sg13cmos5l_IOPadIn.sym} 1080 560 3 0 {name=x21}
C {sg13cmos5l_IOPadOut16mA.sym} 1080 680 3 0 {name=x22}
C {sg13cmos5l_IOPadOut16mA.sym} 1080 800 3 0 {name=x23}
C {sg13cmos5l_IOPadIn.sym} 1080 920 3 0 {name=x24}
C {sg13cmos5l_Filler400.sym} -2970 650 0 0 {name=x49}
C {sg13cmos5l_Filler400.sym} -2930 650 0 0 {name=x51}
C {sg13cmos5l_Filler400.sym} -2890 650 0 0 {name=x52}
C {sg13cmos5l_Filler400.sym} -2850 650 0 0 {name=x54}
C {sg13cmos5l_Filler400.sym} -2810 650 0 0 {name=x55}
C {sg13cmos5l_Filler400.sym} -2770 650 0 0 {name=x57}
C {sg13cmos5l_Filler400.sym} -2730 650 0 0 {name=x58}
C {sg13cmos5l_Filler400.sym} -2690 650 0 0 {name=x60}
C {sg13cmos5l_Filler400.sym} -2650 650 0 0 {name=x61}
C {sg13cmos5l_Filler400.sym} -2610 650 0 0 {name=x63}
C {sg13cmos5l_Filler400.sym} -2570 650 0 0 {name=x64}
C {sg13cmos5l_Filler4000.sym} -2490 390 0 0 {name=x65}
C {sg13cmos5l_Filler400.sym} -2530 650 0 0 {name=x66}
C {sg13cmos5l_Filler400.sym} -2490 650 0 0 {name=x67}
C {sg13cmos5l_IOPadOut16mA.sym} 1080 -40 3 0 {name=x73}
C {sg13cmos5l_IOPadVdd.sym} -880 -430 2 0 {name=x133}
C {sg13cmos5l_IOPadAnalog.sym} -1280 200 1 0 {name=x134}
C {sg13cmos5l_IOPadAnalog.sym} -1280 80 1 0 {name=x135}
C {sg13cmos5l_IOPadAnalog.sym} -1280 -40 1 0 {name=x136}
C {sg13cmos5l_IOPadAnalog.sym} -1280 440 1 0 {name=x139}
C {sg13cmos5l_IOPadAnalog.sym} -1280 320 1 0 {name=x140}
C {sg13cmos5l_IOPadAnalog.sym} -640 -440 2 0 {name=x141}
C {sg13cmos5l_IOPadAnalog.sym} -520 -440 2 0 {name=x142}
C {sg13cmos5l_IOPadAnalog.sym} -160 -440 2 0 {name=x149}
C {sg13cmos5l_IOPadAnalog.sym} -40 -440 2 0 {name=x150}
C {sg13cmos5l_IOPadAnalog.sym} -760 -440 2 0 {name=x137}
C {sg13cmos5l_IOPadAnalog.sym} -400 -440 2 0 {name=x138}
C {sg13cmos5l_IOPadAnalog.sym} -280 -440 2 0 {name=x147}
C {sg13cmos5l_IOPadVss.sym} 920 -440 2 0 {name=x148}
C {sg13cmos5l_IOPadOut16mA.sym} 80 -440 2 0 {name=x152}
C {sg13cmos5l_IOPadOut16mA.sym} 200 -440 2 0 {name=x153}
C {sg13cmos5l_IOPadVss.sym} -1120 1440 0 0 {name=x171}
C {sg13cmos5l_IOPadIOVss.sym} -1000 1440 0 0 {name=x155}
C {sg13cmos5l_IOPadIOVdd.sym} -880 1440 0 0 {name=x156}
C {sg13cmos5l_IOPadVss.sym} -760 1440 0 0 {name=x157}
C {sg13cmos5l_IOPadAnalog.sym} -640 1440 0 0 {name=x158}
C {sg13cmos5l_IOPadAnalog.sym} -520 1440 0 0 {name=x159}
C {sg13cmos5l_IOPadAnalog.sym} -400 1440 0 0 {name=x160}
C {sg13cmos5l_IOPadAnalog.sym} -280 1440 0 0 {name=x164}
C {sg13cmos5l_IOPadAnalog.sym} 80 1440 0 0 {name=x165}
C {sg13cmos5l_IOPadAnalog.sym} 200 1440 0 0 {name=x166}
C {sg13cmos5l_IOPadAnalog.sym} 320 1440 0 0 {name=x167}
C {sg13cmos5l_IOPadIn.sym} 440 1440 0 0 {name=x168}
C {sg13cmos5l_IOPadOut16mA.sym} 560 1440 0 0 {name=x169}
C {sg13cmos5l_IOPadVdd.sym} 680 1430 0 0 {name=x170}
C {sg13cmos5l_IOPadVss.sym} 800 1440 0 0 {name=x172}
C {sg13cmos5l_IOPadAnalog.sym} -40 1440 0 0 {name=x173}
C {sg13cmos5l_IOPadAnalog.sym} -160 1440 0 0 {name=x174}
C {iopin.sym} -1420 -490 2 0 {name=pin_iovss lab=iovss}
C {iopin.sym} -1420 -450 2 0 {name=pin_iovdd lab=iovdd}
C {iopin.sym} -1420 -410 2 0 {name=pin_vdd lab=vdd}
C {iopin.sym} -1420 -370 2 0 {name=pin_vss lab=vss}
C {lab_wire.sym} -2420 330 0 0 {name=p1 sig_type=std_logic lab=vss}
C {lab_wire.sym} -2420 370 0 0 {name=p2 sig_type=std_logic lab=vdd}
C {lab_wire.sym} -2420 410 0 0 {name=p3 sig_type=std_logic lab=iovdd}
C {lab_wire.sym} -2420 450 0 0 {name=p4 sig_type=std_logic lab=iovss}
C {lab_wire.sym} -2420 580 0 0 {name=p5 sig_type=std_logic lab=vss}
C {lab_wire.sym} -2420 620 0 0 {name=p6 sig_type=std_logic lab=vdd}
C {lab_wire.sym} -2420 660 0 0 {name=p7 sig_type=std_logic lab=iovdd}
C {lab_wire.sym} -2420 700 0 0 {name=p8 sig_type=std_logic lab=iovss}
C {ipin.sym} -1430 580 2 1 {name=pin_vinpch1_in lab=vin_p_ch1_in}
C {ipin.sym} -1430 700 2 1 {name=pin_vinnch1 lab=vin_n_ch1_in}
C {ipin.sym} -1430 820 2 1 {name=pin_vinpch2 lab=vin_p_ch2_in}
C {ipin.sym} -1430 940 2 1 {name=pin_vinnch2 lab=vin_n_ch2_in}
C {opin.sym} -1120 540 2 1 {name=pin_vinpch1out lab=vin_p_ch1_out}
C {opin.sym} -1120 660 2 1 {name=pin_vinnch3 lab=vin_n_ch1_out}
C {opin.sym} -1120 780 2 1 {name=pin_vinpch1 lab=vin_p_ch2_out}
C {opin.sym} -1120 900 2 1 {name=pin_vinnch4 lab=vin_n_ch2_out}
C {ipin.sym} -1430 1060 2 1 {name=pin_vthrhin lab=vthr_h_in}
C {ipin.sym} -1430 1180 2 1 {name=pin_vthrlin lab=vthr_l_in}
C {opin.sym} -1120 1020 2 1 {name=pin_vthrhout lab=vthr_h_out}
C {opin.sym} -1120 1140 2 1 {name=pin_vthrlout lab=vthr_l_out}
C {ipin.sym} -1130 180 2 0 {name=pin_voutampin lab=vout_amp_in}
C {ipin.sym} -1130 60 2 0 {name=pin_voutupin lab=vout_up_in}
C {ipin.sym} -1130 -60 2 0 {name=pin_voutdnin lab=vout_dn_in}
C {opin.sym} -1420 220 2 0 {name=pin_voutampout lab=vout_amp_out}
C {opin.sym} -1420 100 2 0 {name=pin_voutupout lab=vout_up_out}
C {opin.sym} -1420 -20 2 0 {name=pin_voutdnout lab=vout_dn_out}
C {ipin.sym} -1420 -160 0 0 {name=pin_chselin lab=ch_sel_in}
C {opin.sym} -1130 -140 0 0 {name=pin_chselout lab=ch_sel_out}
C {ipin.sym} -1420 460 0 0 {name=pin_vbiasin lab=vbias_in}
C {opin.sym} -1130 420 0 0 {name=pin_vbiasout lab=vbias_out}
C {ipin.sym} -60 -580 1 0 {name=pin_vbiasbufNin lab=vbias_bufN_in}
C {opin.sym} -20 -290 1 0 {name=pin_vbiabufNout lab=vbias_bufN_out}
C {ipin.sym} -1420 340 0 0 {name=pin_vbiasbufPin lab=vbias_bufP_in}
C {opin.sym} -1130 300 0 0 {name=pin_vbiabufPout lab=vbias_bufP_out}
C {ipin.sym} -780 -580 1 0 {name=pin_vgainin lab=vgain_in}
C {ipin.sym} -660 -580 1 0 {name=pin_vleakin lab=vleak_in}
C {ipin.sym} -540 -580 1 0 {name=pin_vspkthrin lab=vspkthr_in}
C {ipin.sym} -420 -580 1 0 {name=pin_vrefin lab=vref_in}
C {opin.sym} -740 -290 1 0 {name=pin_vgainout lab=vgain_out}
C {opin.sym} -620 -290 1 0 {name=pin_vleakout lab=vleak_out}
C {opin.sym} -500 -290 1 0 {name=pin_vspkthrout lab=vspkthr_out}
C {opin.sym} -380 -290 1 0 {name=pin_vrefout lab=vref_out}
C {ipin.sym} -260 -290 3 0 {name=pin_vmemupin lab=vmem_up_in}
C {ipin.sym} -140 -290 3 0 {name=pin_vmemudnin lab=vmem_dn_in}
C {ipin.sym} 120 -290 3 0 {name=pin_requpin lab=req_up_in}
C {ipin.sym} 240 -290 3 0 {name=pin_reqdnin lab=req_dn_in}
C {opin.sym} -300 -580 3 0 {name=pin_vmemupout lab=vmem_up_out}
C {opin.sym} -180 -580 3 0 {name=pin_vmemudnout lab=vmem_dn_out}
C {opin.sym} 80 -580 3 0 {name=pin_requpout lab=req_up_out}
C {opin.sym} 200 -580 3 0 {name=pin_reqdnout lab=req_dn_out}
C {ipin.sym} 440 -570 1 0 {name=pin_ackupin lab=ack_up_in}
C {opin.sym} 420 -290 1 0 {name=pin_ackupout lab=ack_up_out}
C {ipin.sym} 320 -570 1 0 {name=pin_ackdnin lab=ack_dn_in}
C {opin.sym} 300 -290 1 0 {name=pin_ackdnout lab=ack_dn_out}
C {sg13cmos5l_IOPadIn.sym} -1280 -160 1 0 {name=x151}
C {sg13cmos5l_IOPadIn.sym} 440 -440 2 0 {name=x239}
C {sg13cmos5l_IOPadIn.sym} 320 -440 2 0 {name=x15}
C {sg13cmos5l_Filler2000.sym} -2750 920 0 0 {name=x31}
C {sg13cmos5l_Filler400.sym} -860 1940 0 0 {name=x20}
C {sg13cmos5l_Filler400.sym} -820 1940 0 0 {name=x32}
C {sg13cmos5l_Filler400.sym} -780 1940 0 0 {name=x33}
C {sg13cmos5l_Filler400.sym} -740 1940 0 0 {name=x34}
C {sg13cmos5l_Filler400.sym} -700 1940 0 0 {name=x36}
C {sg13cmos5l_Filler400.sym} -660 1940 0 0 {name=x37}
C {sg13cmos5l_Filler400.sym} -620 1940 0 0 {name=x39}
C {sg13cmos5l_Filler400.sym} -580 1940 0 0 {name=x40}
C {sg13cmos5l_Filler400.sym} -540 1940 0 0 {name=x42}
C {sg13cmos5l_Filler400.sym} -500 1940 0 0 {name=x43}
C {sg13cmos5l_Filler400.sym} -460 1940 0 0 {name=x45}
C {sg13cmos5l_Filler400.sym} -420 1940 0 0 {name=x46}
C {sg13cmos5l_Filler400.sym} -380 1940 0 0 {name=x48}
C {sg13cmos5l_Filler400.sym} -340 1940 0 0 {name=x68}
C {sg13cmos5l_Filler400.sym} -300 1940 0 0 {name=x69}
C {sg13cmos5l_Filler400.sym} -260 1940 0 0 {name=x111}
C {sg13cmos5l_Filler400.sym} -220 1940 0 0 {name=x112}
C {sg13cmos5l_Filler400.sym} -860 2180 0 0 {name=x175}
C {sg13cmos5l_Filler400.sym} -820 2180 0 0 {name=x176}
C {sg13cmos5l_Filler400.sym} -780 2180 0 0 {name=x177}
C {sg13cmos5l_Filler400.sym} -740 2180 0 0 {name=x178}
C {sg13cmos5l_Filler400.sym} -700 2180 0 0 {name=x179}
C {sg13cmos5l_Filler400.sym} -660 2180 0 0 {name=x180}
C {sg13cmos5l_Filler400.sym} -620 2180 0 0 {name=x181}
C {sg13cmos5l_Filler400.sym} -580 2180 0 0 {name=x182}
C {sg13cmos5l_Filler400.sym} -540 2180 0 0 {name=x183}
C {sg13cmos5l_Filler400.sym} -500 2180 0 0 {name=x184}
C {sg13cmos5l_Filler400.sym} -460 2180 0 0 {name=x185}
C {sg13cmos5l_Filler400.sym} -420 2180 0 0 {name=x186}
C {sg13cmos5l_Filler400.sym} -380 2180 0 0 {name=x187}
C {sg13cmos5l_Filler400.sym} -340 2180 0 0 {name=x188}
C {sg13cmos5l_Filler400.sym} -300 2180 0 0 {name=x189}
C {sg13cmos5l_Filler400.sym} -260 2180 0 0 {name=x190}
C {sg13cmos5l_Filler400.sym} -220 2180 0 0 {name=x191}
C {sg13cmos5l_Filler400.sym} -860 2420 0 0 {name=x192}
C {sg13cmos5l_Filler400.sym} -820 2420 0 0 {name=x193}
C {sg13cmos5l_Filler400.sym} -780 2420 0 0 {name=x194}
C {sg13cmos5l_Filler400.sym} -740 2420 0 0 {name=x215}
C {sg13cmos5l_Filler400.sym} -700 2420 0 0 {name=x216}
C {sg13cmos5l_Filler400.sym} -660 2420 0 0 {name=x217}
C {sg13cmos5l_Filler400.sym} -620 2420 0 0 {name=x218}
C {sg13cmos5l_Filler400.sym} -580 2420 0 0 {name=x219}
C {sg13cmos5l_Filler400.sym} -540 2420 0 0 {name=x220}
C {sg13cmos5l_Filler400.sym} -500 2420 0 0 {name=x221}
C {sg13cmos5l_Filler400.sym} -460 2420 0 0 {name=x222}
C {sg13cmos5l_Filler400.sym} -420 2420 0 0 {name=x223}
C {sg13cmos5l_Filler400.sym} -380 2420 0 0 {name=x224}
C {sg13cmos5l_Filler400.sym} -340 2420 0 0 {name=x225}
C {sg13cmos5l_Filler400.sym} -300 2420 0 0 {name=x226}
C {sg13cmos5l_Filler400.sym} -260 2420 0 0 {name=x227}
C {sg13cmos5l_Filler400.sym} -220 2420 0 0 {name=x228}
C {sg13cmos5l_Filler400.sym} -860 2650 0 0 {name=x229}
C {sg13cmos5l_Filler400.sym} -820 2650 0 0 {name=x230}
C {sg13cmos5l_Filler400.sym} -780 2650 0 0 {name=x231}
C {sg13cmos5l_Filler400.sym} -740 2650 0 0 {name=x232}
C {sg13cmos5l_Filler400.sym} -700 2650 0 0 {name=x233}
C {sg13cmos5l_Filler400.sym} -660 2650 0 0 {name=x234}
C {sg13cmos5l_Filler400.sym} -620 2650 0 0 {name=x235}
C {sg13cmos5l_Filler400.sym} -580 2650 0 0 {name=x236}
C {sg13cmos5l_Filler400.sym} -540 2650 0 0 {name=x237}
C {sg13cmos5l_Filler400.sym} -500 2650 0 0 {name=x238}
C {sg13cmos5l_Filler400.sym} -460 2650 0 0 {name=x240}
C {sg13cmos5l_Filler400.sym} -420 2650 0 0 {name=x241}
C {sg13cmos5l_Filler400.sym} -380 2650 0 0 {name=x242}
C {sg13cmos5l_Filler400.sym} -340 2650 0 0 {name=x243}
C {sg13cmos5l_Filler400.sym} -300 2650 0 0 {name=x244}
C {sg13cmos5l_Filler400.sym} -260 2650 0 0 {name=x245}
C {sg13cmos5l_Filler400.sym} -220 2650 0 0 {name=x246}
C {lab_wire.sym} -140 1870 0 0 {name=p9 sig_type=std_logic lab=vss}
C {lab_wire.sym} -140 1910 0 0 {name=p10 sig_type=std_logic lab=vdd}
C {lab_wire.sym} -140 1950 0 0 {name=p11 sig_type=std_logic lab=iovdd}
C {lab_wire.sym} -140 1990 0 0 {name=p12 sig_type=std_logic lab=iovss}
C {lab_wire.sym} -140 2110 0 0 {name=p21 sig_type=std_logic lab=vss}
C {lab_wire.sym} -140 2150 0 0 {name=p22 sig_type=std_logic lab=vdd}
C {lab_wire.sym} -140 2190 0 0 {name=p23 sig_type=std_logic lab=iovdd}
C {lab_wire.sym} -140 2230 0 0 {name=p24 sig_type=std_logic lab=iovss}
C {lab_wire.sym} -140 2350 0 0 {name=p29 sig_type=std_logic lab=vss}
C {lab_wire.sym} -140 2390 0 0 {name=p30 sig_type=std_logic lab=vdd}
C {lab_wire.sym} -140 2430 0 0 {name=p31 sig_type=std_logic lab=iovdd}
C {lab_wire.sym} -140 2470 0 0 {name=p32 sig_type=std_logic lab=iovss}
C {lab_wire.sym} -150 2580 0 0 {name=p33 sig_type=std_logic lab=vss}
C {lab_wire.sym} -150 2620 0 0 {name=p34 sig_type=std_logic lab=vdd}
C {lab_wire.sym} -150 2660 0 0 {name=p35 sig_type=std_logic lab=iovdd}
C {lab_wire.sym} -150 2700 0 0 {name=p36 sig_type=std_logic lab=iovss}
C {sg13cmos5l_Filler400.sym} 1850 570 0 0 {name=x79}
C {sg13cmos5l_Filler400.sym} 1890 570 0 0 {name=x81}
C {sg13cmos5l_Filler400.sym} 1930 570 0 0 {name=x82}
C {sg13cmos5l_Filler400.sym} 1970 570 0 0 {name=x84}
C {sg13cmos5l_Filler400.sym} 2010 570 0 0 {name=x85}
C {sg13cmos5l_Filler400.sym} 2050 570 0 0 {name=x87}
C {sg13cmos5l_Filler400.sym} 2090 570 0 0 {name=x88}
C {sg13cmos5l_Filler400.sym} 2130 570 0 0 {name=x90}
C {sg13cmos5l_Filler400.sym} 2170 570 0 0 {name=x91}
C {sg13cmos5l_Filler400.sym} 2210 570 0 0 {name=x93}
C {sg13cmos5l_Filler400.sym} 2250 570 0 0 {name=x94}
C {sg13cmos5l_Filler400.sym} 2290 570 0 0 {name=x96}
C {sg13cmos5l_Filler400.sym} 2330 570 0 0 {name=x97}
C {lab_wire.sym} 2400 500 0 0 {name=p17 sig_type=std_logic lab=vss}
C {lab_wire.sym} 2400 540 0 0 {name=p18 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 2400 580 0 0 {name=p19 sig_type=std_logic lab=iovdd}
C {lab_wire.sym} 2400 620 0 0 {name=p20 sig_type=std_logic lab=iovss}
C {sg13cmos5l_Filler2000.sym} 2070 840 0 0 {name=x98}
C {sg13cmos5l_Filler400.sym} -210 -1680 0 0 {name=x99}
C {sg13cmos5l_Filler400.sym} -170 -1680 0 0 {name=x100}
C {sg13cmos5l_Filler400.sym} -130 -1680 0 0 {name=x101}
C {sg13cmos5l_Filler400.sym} -90 -1680 0 0 {name=x102}
C {sg13cmos5l_Filler400.sym} -50 -1680 0 0 {name=x103}
C {sg13cmos5l_Filler400.sym} -10 -1680 0 0 {name=x104}
C {sg13cmos5l_Filler400.sym} 30 -1680 0 0 {name=x105}
C {sg13cmos5l_Filler400.sym} 70 -1680 0 0 {name=x106}
C {sg13cmos5l_Filler400.sym} 110 -1680 0 0 {name=x107}
C {sg13cmos5l_Filler400.sym} 150 -1680 0 0 {name=x108}
C {sg13cmos5l_Filler400.sym} 190 -1680 0 0 {name=x109}
C {sg13cmos5l_Filler400.sym} 230 -1680 0 0 {name=x110}
C {sg13cmos5l_Filler400.sym} 270 -1680 0 0 {name=x113}
C {sg13cmos5l_Filler400.sym} 310 -1680 0 0 {name=x114}
C {sg13cmos5l_Filler400.sym} 350 -1680 0 0 {name=x115}
C {sg13cmos5l_Filler400.sym} 390 -1680 0 0 {name=x116}
C {sg13cmos5l_Filler400.sym} 430 -1680 0 0 {name=x117}
C {sg13cmos5l_Filler400.sym} -210 -1440 0 0 {name=x118}
C {sg13cmos5l_Filler400.sym} -170 -1440 0 0 {name=x119}
C {sg13cmos5l_Filler400.sym} -130 -1440 0 0 {name=x120}
C {sg13cmos5l_Filler400.sym} -90 -1440 0 0 {name=x121}
C {sg13cmos5l_Filler400.sym} -50 -1440 0 0 {name=x122}
C {sg13cmos5l_Filler400.sym} -10 -1440 0 0 {name=x123}
C {sg13cmos5l_Filler400.sym} 30 -1440 0 0 {name=x124}
C {sg13cmos5l_Filler400.sym} 70 -1440 0 0 {name=x125}
C {sg13cmos5l_Filler400.sym} 110 -1440 0 0 {name=x126}
C {sg13cmos5l_Filler400.sym} 150 -1440 0 0 {name=x127}
C {sg13cmos5l_Filler400.sym} 190 -1440 0 0 {name=x128}
C {sg13cmos5l_Filler400.sym} 230 -1440 0 0 {name=x129}
C {sg13cmos5l_Filler400.sym} 270 -1440 0 0 {name=x130}
C {sg13cmos5l_Filler400.sym} 310 -1440 0 0 {name=x131}
C {sg13cmos5l_Filler400.sym} 350 -1440 0 0 {name=x132}
C {sg13cmos5l_Filler400.sym} 390 -1440 0 0 {name=x195}
C {sg13cmos5l_Filler400.sym} 430 -1440 0 0 {name=x196}
C {sg13cmos5l_Filler400.sym} -210 -1200 0 0 {name=x197}
C {sg13cmos5l_Filler400.sym} -170 -1200 0 0 {name=x198}
C {sg13cmos5l_Filler400.sym} -130 -1200 0 0 {name=x199}
C {sg13cmos5l_Filler400.sym} -90 -1200 0 0 {name=x200}
C {sg13cmos5l_Filler400.sym} -50 -1200 0 0 {name=x201}
C {sg13cmos5l_Filler400.sym} -10 -1200 0 0 {name=x202}
C {sg13cmos5l_Filler400.sym} 30 -1200 0 0 {name=x203}
C {sg13cmos5l_Filler400.sym} 70 -1200 0 0 {name=x204}
C {sg13cmos5l_Filler400.sym} 110 -1200 0 0 {name=x205}
C {sg13cmos5l_Filler400.sym} 150 -1200 0 0 {name=x206}
C {sg13cmos5l_Filler400.sym} 190 -1200 0 0 {name=x207}
C {sg13cmos5l_Filler400.sym} 230 -1200 0 0 {name=x208}
C {sg13cmos5l_Filler400.sym} 270 -1200 0 0 {name=x209}
C {sg13cmos5l_Filler400.sym} 310 -1200 0 0 {name=x210}
C {sg13cmos5l_Filler400.sym} 350 -1200 0 0 {name=x211}
C {sg13cmos5l_Filler400.sym} 390 -1200 0 0 {name=x212}
C {sg13cmos5l_Filler400.sym} 430 -1200 0 0 {name=x213}
C {sg13cmos5l_Filler400.sym} -210 -970 0 0 {name=x214}
C {sg13cmos5l_Filler400.sym} -170 -970 0 0 {name=x247}
C {sg13cmos5l_Filler400.sym} -130 -970 0 0 {name=x248}
C {sg13cmos5l_Filler400.sym} -90 -970 0 0 {name=x249}
C {sg13cmos5l_Filler400.sym} -50 -970 0 0 {name=x250}
C {sg13cmos5l_Filler400.sym} -10 -970 0 0 {name=x251}
C {sg13cmos5l_Filler400.sym} 30 -970 0 0 {name=x252}
C {sg13cmos5l_Filler400.sym} 70 -970 0 0 {name=x253}
C {sg13cmos5l_Filler400.sym} 110 -970 0 0 {name=x254}
C {sg13cmos5l_Filler400.sym} 150 -970 0 0 {name=x255}
C {sg13cmos5l_Filler400.sym} 190 -970 0 0 {name=x256}
C {sg13cmos5l_Filler400.sym} 230 -970 0 0 {name=x257}
C {sg13cmos5l_Filler400.sym} 270 -970 0 0 {name=x258}
C {sg13cmos5l_Filler400.sym} 310 -970 0 0 {name=x259}
C {sg13cmos5l_Filler400.sym} 350 -970 0 0 {name=x260}
C {sg13cmos5l_Filler400.sym} 390 -970 0 0 {name=x261}
C {sg13cmos5l_Filler400.sym} 430 -970 0 0 {name=x262}
C {lab_wire.sym} 510 -1750 0 0 {name=p25 sig_type=std_logic lab=vss}
C {lab_wire.sym} 510 -1710 0 0 {name=p26 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 510 -1670 0 0 {name=p27 sig_type=std_logic lab=iovdd}
C {lab_wire.sym} 510 -1630 0 0 {name=p28 sig_type=std_logic lab=iovss}
C {lab_wire.sym} 510 -1510 0 0 {name=p37 sig_type=std_logic lab=vss}
C {lab_wire.sym} 510 -1470 0 0 {name=p38 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 510 -1430 0 0 {name=p39 sig_type=std_logic lab=iovdd}
C {lab_wire.sym} 510 -1390 0 0 {name=p40 sig_type=std_logic lab=iovss}
C {lab_wire.sym} 510 -1270 0 0 {name=p41 sig_type=std_logic lab=vss}
C {lab_wire.sym} 510 -1230 0 0 {name=p42 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 510 -1190 0 0 {name=p43 sig_type=std_logic lab=iovdd}
C {lab_wire.sym} 510 -1150 0 0 {name=p44 sig_type=std_logic lab=iovss}
C {lab_wire.sym} 500 -1040 0 0 {name=p45 sig_type=std_logic lab=vss}
C {lab_wire.sym} 500 -1000 0 0 {name=p46 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 500 -960 0 0 {name=p47 sig_type=std_logic lab=iovdd}
C {lab_wire.sym} 500 -920 0 0 {name=p48 sig_type=std_logic lab=iovss}
C {lab_wire.sym} -2660 840 0 0 {name=p49 sig_type=std_logic lab=vss}
C {lab_wire.sym} -2660 880 0 0 {name=p50 sig_type=std_logic lab=vdd}
C {lab_wire.sym} -2660 920 0 0 {name=p51 sig_type=std_logic lab=iovdd}
C {lab_wire.sym} -2660 960 0 0 {name=p52 sig_type=std_logic lab=iovss}
C {lab_wire.sym} 2160 760 0 0 {name=p53 sig_type=std_logic lab=vss}
C {lab_wire.sym} 2160 800 0 0 {name=p54 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 2160 840 0 0 {name=p55 sig_type=std_logic lab=iovdd}
C {lab_wire.sym} 2160 880 0 0 {name=p56 sig_type=std_logic lab=iovss}
C {sg13cmos5l_IOPadIOVdd.sym} -1280 -280 1 0 {name=x2}
C {sg13cmos5l_IOPadVdd.sym} -1270 1280 1 0 {name=x3}
C {sg13cmos5l_IOPadIOVss.sym} 920 1440 0 0 {name=x4}
C {sg13cmos5l_IOPadOut16mA.sym} 1080 440 3 0 {name=x5}
C {sg13cmos5l_IOPadIn.sym} 1080 320 3 0 {name=x11}
C {sg13cmos5l_IOPadIOVss.sym} 800 -440 2 0 {name=x12}
C {sg13cmos5l_IOPadIOVdd.sym} 680 -440 2 0 {name=x13}
C {sg13cmos5l_IOPadIn.sym} 560 -440 2 0 {name=x14}
C {sg13cmos5l_IOPadVss.sym} -1000 -440 2 0 {name=x70}
C {sg13cmos5l_IOPadIOVss.sym} -1120 -440 2 0 {name=x143}
C {sg13cmos5l_Filler4000.sym} -2530 390 0 0 {name=x28}
C {sg13cmos5l_Filler4000.sym} -2570 390 0 0 {name=x29}
C {sg13cmos5l_Filler4000.sym} -2610 390 0 0 {name=x30}
C {sg13cmos5l_Filler4000.sym} -2650 390 0 0 {name=x35}
C {sg13cmos5l_Filler4000.sym} -2690 390 0 0 {name=x38}
C {sg13cmos5l_Filler4000.sym} -2730 390 0 0 {name=x41}
C {sg13cmos5l_Filler4000.sym} -2770 390 0 0 {name=x44}
C {sg13cmos5l_Filler4000.sym} -2810 390 0 0 {name=x47}
C {sg13cmos5l_Filler4000.sym} -2850 390 0 0 {name=x50}
C {sg13cmos5l_Filler4000.sym} -2890 390 0 0 {name=x53}
C {sg13cmos5l_Filler4000.sym} -2930 390 0 0 {name=x56}
C {sg13cmos5l_Filler4000.sym} -2970 390 0 0 {name=x59}
C {sg13cmos5l_Filler4000.sym} 2320 300 0 0 {name=x62}
C {lab_wire.sym} 2390 240 0 0 {name=p57 sig_type=std_logic lab=vss}
C {lab_wire.sym} 2390 280 0 0 {name=p58 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 2390 320 0 0 {name=p59 sig_type=std_logic lab=iovdd}
C {lab_wire.sym} 2390 360 0 0 {name=p60 sig_type=std_logic lab=iovss}
C {sg13cmos5l_Filler4000.sym} 2280 300 0 0 {name=x144}
C {sg13cmos5l_Filler4000.sym} 2240 300 0 0 {name=x145}
C {sg13cmos5l_Filler4000.sym} 2200 300 0 0 {name=x146}
C {sg13cmos5l_Filler4000.sym} 2160 300 0 0 {name=x154}
C {sg13cmos5l_Filler4000.sym} 2120 300 0 0 {name=x161}
C {sg13cmos5l_Filler4000.sym} 2080 300 0 0 {name=x162}
C {sg13cmos5l_Filler4000.sym} 2040 300 0 0 {name=x163}
C {sg13cmos5l_Filler4000.sym} 2000 300 0 0 {name=x263}
C {sg13cmos5l_Filler4000.sym} 1960 300 0 0 {name=x264}
C {sg13cmos5l_Filler4000.sym} 1920 300 0 0 {name=x265}
C {sg13cmos5l_Filler4000.sym} 1880 300 0 0 {name=x266}
C {sg13cmos5l_Filler4000.sym} 1840 300 0 0 {name=x267}
C {sg13cmos5l_Filler4000.sym} 150 1920 0 0 {name=x71}
C {sg13cmos5l_Filler4000.sym} 190 1920 0 0 {name=x72}
C {sg13cmos5l_Filler4000.sym} 230 1920 0 0 {name=x74}
C {sg13cmos5l_Filler4000.sym} 270 1920 0 0 {name=x75}
C {sg13cmos5l_Filler4000.sym} 310 1920 0 0 {name=x76}
C {sg13cmos5l_Filler4000.sym} 350 1920 0 0 {name=x77}
C {sg13cmos5l_Filler4000.sym} 390 1920 0 0 {name=x78}
C {sg13cmos5l_Filler4000.sym} 430 1920 0 0 {name=x80}
C {sg13cmos5l_Filler4000.sym} 470 1920 0 0 {name=x83}
C {sg13cmos5l_Filler4000.sym} 510 1920 0 0 {name=x86}
C {sg13cmos5l_Filler4000.sym} 550 1920 0 0 {name=x89}
C {sg13cmos5l_Filler4000.sym} 590 1920 0 0 {name=x92}
C {sg13cmos5l_Filler4000.sym} 630 1920 0 0 {name=x95}
C {sg13cmos5l_Filler4000.sym} 670 1920 0 0 {name=x268}
C {sg13cmos5l_Filler4000.sym} 710 1920 0 0 {name=x269}
C {sg13cmos5l_Filler4000.sym} 750 1920 0 0 {name=x270}
C {sg13cmos5l_Filler4000.sym} 790 1920 0 0 {name=x271}
C {lab_wire.sym} 870 1860 0 0 {name=p13 sig_type=std_logic lab=vss}
C {lab_wire.sym} 870 1900 0 0 {name=p14 sig_type=std_logic lab=vdd}
C {lab_wire.sym} 870 1940 0 0 {name=p15 sig_type=std_logic lab=iovdd}
C {lab_wire.sym} 870 1980 0 0 {name=p16 sig_type=std_logic lab=iovss}
C {sg13cmos5l_Filler4000.sym} -1110 -1210 0 0 {name=x272}
C {sg13cmos5l_Filler4000.sym} -1070 -1210 0 0 {name=x273}
C {sg13cmos5l_Filler4000.sym} -1030 -1210 0 0 {name=x274}
C {sg13cmos5l_Filler4000.sym} -990 -1210 0 0 {name=x275}
C {sg13cmos5l_Filler4000.sym} -950 -1210 0 0 {name=x276}
C {sg13cmos5l_Filler4000.sym} -910 -1210 0 0 {name=x277}
C {sg13cmos5l_Filler4000.sym} -870 -1210 0 0 {name=x278}
C {sg13cmos5l_Filler4000.sym} -830 -1210 0 0 {name=x279}
C {sg13cmos5l_Filler4000.sym} -790 -1210 0 0 {name=x280}
C {sg13cmos5l_Filler4000.sym} -750 -1210 0 0 {name=x281}
C {sg13cmos5l_Filler4000.sym} -710 -1210 0 0 {name=x282}
C {sg13cmos5l_Filler4000.sym} -670 -1210 0 0 {name=x283}
C {sg13cmos5l_Filler4000.sym} -630 -1210 0 0 {name=x284}
C {sg13cmos5l_Filler4000.sym} -590 -1210 0 0 {name=x285}
C {sg13cmos5l_Filler4000.sym} -550 -1210 0 0 {name=x286}
C {sg13cmos5l_Filler4000.sym} -510 -1210 0 0 {name=x287}
C {sg13cmos5l_Filler4000.sym} -470 -1210 0 0 {name=x288}
C {lab_wire.sym} -390 -1270 0 0 {name=p61 sig_type=std_logic lab=vss}
C {lab_wire.sym} -390 -1230 0 0 {name=p62 sig_type=std_logic lab=vdd}
C {lab_wire.sym} -390 -1190 0 0 {name=p63 sig_type=std_logic lab=iovdd}
C {lab_wire.sym} -390 -1150 0 0 {name=p64 sig_type=std_logic lab=iovss}
C {ipin.sym} -620 1580 3 0 {name=pin_V2I_INP_in lab=V2I_INP_in}
C {ipin.sym} -500 1580 3 0 {name=pin_V2I_INN_in lab=V2I_INN_in}
C {ipin.sym} -420 1290 1 0 {name=pin_NN3_MEM_PROBE_in lab=NN3_MEM_PROBE_in}
C {ipin.sym} -300 1290 1 0 {name=pin_NN2_MEM_PROBE_in lab=NN2_MEM_PROBE_in}
C {ipin.sym} -180 1290 1 0 {name=pin_NN1_MEM_PROBE_in lab=NN1_MEM_PROBE_in}
C {ipin.sym} -20 1580 3 0 {name=pin_BG_100mV lab=BG_100mV_in}
C {ipin.sym} 100 1580 3 0 {name=pin_BG_BIAS lab=BG_BIAS_in}
C {ipin.sym} 220 1580 3 0 {name=pin_BG_100kRES lab=BG_100kRES_in}
C {ipin.sym} 300 1290 1 0 {name=pin_BG_PROBE lab=BG_PROBE_in}
C {ipin.sym} 440 1580 3 0 {name=pin_NN3_ACK_in lab=NN3_ACK_in}
C {ipin.sym} 520 1290 1 0 {name=pin_NN3_REQ_in lab=NN3_REQ_in}
C {opin.sym} -660 1290 3 0 {name=pin_V2I_INP_out lab=V2I_INP_out}
C {opin.sym} -540 1290 3 0 {name=pin_V2I_INN_out lab=V2I_INN_out}
C {opin.sym} -380 1580 1 0 {name=pin_NN3_MEM_PROBE_out lab=NN3_MEM_PROBE_out}
C {opin.sym} -260 1580 1 0 {name=pin_NN2_MEM_PROBE_out lab=NN2_MEM_PROBE_out}
C {opin.sym} -140 1580 1 0 {name=pin_NN1_MEM_PROBE_out lab=NN1_MEM_PROBE_out}
C {opin.sym} -60 1290 3 0 {name=pin_BG_100mV_out lab=BG_100mV_out}
C {opin.sym} 60 1290 3 0 {name=pin_BG_BIAS_out lab=BG_BIAS_out}
C {opin.sym} 180 1290 3 0 {name=pin_BG_100kRES_out lab=BG_100kRES_out}
C {opin.sym} 340 1580 1 0 {name=pin_BG_PROBE_out lab=BG_PROBE_out}
C {opin.sym} 460 1290 3 0 {name=pin_NN3_ACK_out lab=NN3_ACK_out}
C {opin.sym} 560 1580 1 0 {name=pin_NN3_REQ_out lab=NN3_REQ_out}
C {ipin.sym} 1230 1160 2 0 {name=pin_NN2_ACK_in lab=NN2_ACK_in}
C {ipin.sym} 1230 920 2 0 {name=pin_NN1_ACK_in lab=NN1_ACK_in}
C {ipin.sym} 920 1080 0 0 {name=pin_NN2_REQ_in lab=NN2_REQ_in}
C {ipin.sym} 920 840 0 0 {name=pin_NN1_REQ_in lab=NN1_REQ_in}
C {ipin.sym} 920 720 0 0 {name=pin_C2F_COMP_in lab=C2F_COMP_in}
C {ipin.sym} 1230 560 2 0 {name=pin_C2F_ACK_in lab=C2F_ACK_in}
C {ipin.sym} 920 480 0 0 {name=pin_C2F_REQ_in lab=C2F_REQ_in}
C {ipin.sym} 1230 320 2 0 {name=pin_SPI_RST_N_in lab=SPI_RST_N_in}
C {ipin.sym} 1230 200 2 0 {name=pin_SPI_MOSI_in lab=SPI_MOSI_in}
C {ipin.sym} 1230 80 2 0 {name=pin_SPI_SCK_in lab=SPI_SCK_in}
C {ipin.sym} 1230 -160 2 0 {name=pin_SPI_CS_N_in lab=SPI_CS_N_in}
C {ipin.sym} 920 0 0 0 {name=pin_SPI_MISO_in lab=SPI_MISO_in}
C {opin.sym} 920 1140 2 0 {name=pin_NN2_ACK_out lab=NN2_ACK_out}
C {opin.sym} 920 900 2 0 {name=pin_NN1_ACK_out lab=NN1_ACK_out}
C {opin.sym} 1230 1040 0 0 {name=pin_NN2_REQ_out lab=NN2_REQ_out}
C {opin.sym} 1230 800 0 0 {name=pin_NN1_REQ_out lab=NN1_REQ_out}
C {opin.sym} 1230 680 0 0 {name=pin_C2F_COMP_out lab=C2F_COMP_out}
C {opin.sym} 920 540 2 0 {name=pin_C2F_ACK_out lab=C2F_ACK_out}
C {opin.sym} 1230 440 0 0 {name=pin_C2F_REQ_out lab=C2F_REQ_out}
C {opin.sym} 920 300 2 0 {name=pin_SPI_RST_N_out lab=SPI_RST_N_out}
C {opin.sym} 920 180 2 0 {name=pin_SPI_MOSI_out lab=SPI_MOSI_out}
C {opin.sym} 920 60 2 0 {name=pin_SPI_SCK_out lab=SPI_SCK_out}
C {opin.sym} 1230 -40 0 0 {name=pin_SPI_MISO_out lab=SPI_MISO_out}
C {opin.sym} 930 -180 2 0 {name=pin_SPI_CS_N_out lab=SPI_CS_N_out}
C {ipin.sym} 560 -570 1 0 {name=pin_enfeedback_in lab=en_feedback_in}
C {opin.sym} 540 -290 1 0 {name=pin_enfeedback_out lab=en_feedback_out}
