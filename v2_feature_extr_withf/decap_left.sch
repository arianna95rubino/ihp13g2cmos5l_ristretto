v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
N 120 -310 120 -260 {lab=top}
N 120 -140 120 -90 {lab=vss}
C {iopin.sym} 120 -310 3 0 {name=pin_top lab=top}
C {iopin.sym} 120 -90 1 0 {name=pin_bot lab=bot}
C {decap_unit.sym} 120 -200 0 0 {name=x1}
